# Keil uVision project AKMX2_XuZ.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AKMX2_XuZ +hex
  c flags: OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Libraries\CMISS;..\Libraries\Libraries\inc;..\Libraries\FreeRTOS\inc;..\Libraries\FreeRTOS\port;..\Libraries\FreeRTOS\src;..\Project\USER\inc;..\Project;..\Project\CODE\eMPL;D:\Program Files\KEIL5\ARM\Packs\ARM\CMSIS\6.1.0\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../Libraries/CMISS/startup/arm/: startup_stm32f10x_hd.s
    ../Libraries/CMISS/: system_stm32f10x.c core_cm3.c
  group Libraries
    ../Libraries/Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Project
    ./USER/src/: akm_Initial.c akm_servo.c akm_motor.c akm_volt.c akm_encoder.c akm_tim.c akm_uart_pc.c akm_uart_pi.c akm_control.c mpu_6050.c VofaPlus.c mymath.c taskloop.c
    ./CODE/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
  group USER
    ./: main.c stm32f10x_it.c
